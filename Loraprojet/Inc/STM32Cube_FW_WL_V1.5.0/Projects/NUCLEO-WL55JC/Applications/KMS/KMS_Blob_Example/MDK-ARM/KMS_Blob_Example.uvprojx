# Keil uVision project KMS_Blob_Example.uvprojx, settings and files
target KMS_Blob_Example (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: KMS_Blob_Example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,KMS_ENABLED,CORE_CM4,USE_HAL_DRIVER,STM32WL55xx
  c include: ../Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/ST;../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls;../../../../../../Middlewares/Third_Party/mbed-crypto/library;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c kms_low_level.c nvms_low_level.c app_kms.c com.c common.c flash_if.c kms_object_update_app.c ymodem.c ca_low_level.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_pka.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
  group Middlewares/KMS
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core/: kms_der_x962.c kms_ecc.c kms_entry.c kms_init.c kms_mem.c kms_objects.c kms_platf_objects.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules/: kms_counter.c kms_digest.c kms_dyn_obj.c kms_enc_dec.c kms_key_mgt.c kms_nvm_storage.c kms_sign_verify.c kms_vm_storage.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS/: kms_interface.c tkms.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/: ca_aes.c ca_core.c ca_ecc.c ca_hash.c ca_if_utils.c ca_rng.c ca_rsa.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL/: ca_aes_hal.c ca_ecc_hal.c ca_rsa_hal.c mac_stm32hal.c rsa_stm32hal.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED/: ca_aes_mbed.c ca_ecc_mbed.c ca_hash_mbed.c ca_rng_mbed.c ca_rsa_mbed.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: sha1.c sha256.c platform_util.c
    ../../../../../../Middlewares/Third_Party/mbed-crypto/include/: CMakeLists.txt
software components: CMSIS:CORE 4.3.0
